# Keil uVision project DisplayRoulette.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F410 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(50000000)
  output: DisplayRoulette
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 display_slot_init.c displplay_slot_main.c rtc.c MBI.c i2c.c nrf24.c
